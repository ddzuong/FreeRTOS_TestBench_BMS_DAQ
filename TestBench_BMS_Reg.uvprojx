# Keil uVision project TestBench_BMS_Reg.uvprojx, settings and files
target TestBench_BMS (6240000::V6.24::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TestBench_BMS_Reg
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Core;.\Driver;.\freertos\include;.\freertos\portable\GCC\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: main.c main.h
  group Driver
    ./Driver/: adc.c adc.h afio.c afio.h can.c can.h dma.c dma.h exti.c exti.h gpio.c gpio.h rcc.c rcc.h tim.c tim.h TYPE.h uart.c uart.h
  group FreeRTOS
    ./freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./freertos/portable/GCC/ARM_CM3/: port.c portmacro.h
    ./freertos/portable/MemMang/: heap_4.c
    ./freertos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
